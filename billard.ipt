# Autodesk Inventor part: billard
## iProperties
Created: 2008-07
Part Number: billard
Document SubType Name: Modeling
Designer: jp
Author: jp
## Feature names
1. Extrusion1
2. Extrusion2
