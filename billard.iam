# Autodesk Inventor assembly: billard
## iProperties
Created: 2008-07
Part Number: billard
Document SubType Name: Assembly
Designer: jp
Author: jp
