# Autodesk Inventor part: boule
## iProperties
Created: 2008-07
Part Number: boule
Document SubType Name: Modeling
Designer: jp
Author: jp
## Feature names
1. Révolution1 [Revolution]
